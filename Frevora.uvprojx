# Keil uVision project Frevora.uvprojx, settings and files
target Frevora (6230000::V6.23::ARMCLANG)
  device: ARMCM0P ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: Frevora +hex
  c flags: Optim=5 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=4 wLevel=3
  c define: SC32f12xx, Include_Main_H
  c include: .\CMSIS\Include;.\CMSIS\Include\m-profile;.\Peripheral-Library\SC32F1XXX\include;.\Middleware\FreeRTOS\include;.\Middleware\FreeRTOS\portable\GCC\ARM_CM0;.\User
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Startup
    ./Startup/: startup_sc32f12xx.s
  group Peripheral-Library
    ./Peripheral-Library/SC32F1XXX/source/: sc32f1xxx_adc.c sc32f1xxx_btm.c sc32f1xxx_can.c sc32f1xxx_cmp.c sc32f1xxx_crc.c sc32f1xxx_dac.c sc32f1xxx_dma.c sc32f1xxx_gpio.c sc32f1xxx_iap.c sc32f1xxx_int.c sc32f1xxx_lcd.c sc32f1xxx_led.c sc32f1xxx_ledpwm.c sc32f1xxx_op.c sc32f1xxx_option.c sc32f1xxx_pga.c sc32f1xxx_pwm.c sc32f1xxx_pwr.c sc32f1xxx_qep.c sc32f1xxx_rcc.c sc32f1xxx_spi.c sc32f1xxx_spi1_twi1.c sc32f1xxx_temper.c sc32f1xxx_tim.c sc32f1xxx_twi.c sc32f1xxx_uart.c sc32f1xxx_vref.c sc32f1xxx_wdt.c system_sc32f1xxx.c
  group Middleware\FreeRTOS
    ./Middleware/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./Middleware/FreeRTOS/portable/GCC/ARM_CM0/: port.c portasm.c
    ./Middleware/FreeRTOS/portable/MemMang/: heap_4.c
  group User
    ./User/: SC_Init.c SC_Interrupt.c Main.c FreeRTOS-Hook.c DMA-Buffer-Manager.c Terminal.c
